# IAR project UpHole.ewp, settings and files
configuration Uphole (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405VG ST STM32F405VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_PERIPH_LIBRARY; STM32F40_41xxx
  ICCARM.CCDiagSuppress: Be025
  ICCARM.CCIncludePath2: $PROJ_DIR$; inc; ..\..\Libraries\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\Libraries\STM32F4xx_StdPeriph_Driver\inc; inc\CommDrivers; inc\DataManagers; inc\UI_DataFields; inc\HardwareInterfaces; inc\Logging; inc\Logging; inc\NVRAM; inc\RASP; inc\UI_Frame; inc\UI_Panels; inc\UI_Tabs; inc\UI_Tools; inc\YitranModem; inc\Graph_Plot; inc\SerialFlash; ..\..\Libraries\Project\STM32F4xx_StdPeriph_Templates; inc\SerialProtocol; inc\RealTimeCLock
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UpHole.bin
  ILINK.IlinkOutputFile: BDL_Uphole.out
  ILINK.IlinkKeepSymbols: g_nDataBattery0Bmp; g_nDataBattery25Bmp; g_nDataBattery50Bmp; g_nDataBattery75Bmp; g_nDataBattery100Bmp; g_nDataFileBmp; g_nDataDiskBmp; g_nDataConnectGoodBmp; g_nDataConnectBadBmp; g_nDataRadioBmp
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkExtraOptions: --image_input BMP\Battery0.bmp,g_nDataBattery0Bmp,bmp_section; --image_input BMP\Battery25.bmp,g_nDataBattery25Bmp,bmp_section; --image_input BMP\Battery50.bmp,g_nDataBattery50Bmp,bmp_section; --image_input BMP\Battery75.bmp,g_nDataBattery75Bmp,bmp_section; --image_input BMP\Battery100.bmp,g_nDataBattery100Bmp,bmp_section; --image_input BMP\File.bmp,g_nDataFileBmp,bmp_section; --image_input BMP\DiskWrite.bmp,g_nDataDiskBmp,bmp_section; --image_input BMP\ConnectGood.bmp,g_nDataConnectGoodBmp,bmp_section; --image_input BMP\ConnectBad.bmp,g_nDataConnectBadBmp,bmp_section; --image_input BMP\Radio.bmp,g_nDataRadioBmp,bmp_section
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BMP
    BMP/: Battery0.bmp Battery100.bmp Battery25.bmp Battery50.bmp Battery75.bmp ConnectBad.bmp ConnectGood.bmp DiskWrite.bmp File.bmp Radio.bmp
  group include
    inc/: crc.h InterruptEnabling.h main.h NVIC.h PeriodicEvents.h portable.h STM32F4_core_irqs.h SysTick.h timer.h UtilityFunctions.h wdt.h
  group include/CommDrivers
    inc/CommDrivers/: CommDriver_Flash.h CommDriver_FRAM.h CommDriver_SPI.h CommDriver_UART.h
  group include/DataManagers
    inc/DataManagers/: BMP.h DownholeBatteryAndLife.h fontDef.h GammaSensor.h language.h Manager_DataLink.h RecordManager.h TextStrings.h version.h
  group include/Graph_Plot
    inc/Graph_Plot/: Compass_Plot.h Gamma_Compass.h Gamma_Graph_Plot.h Gamma_Tab_Graph.h Graph_Plot.h Plan_Graph_Plot.h Plan_Tab_Graph.h Side_Graph_Plot.h Side_Tab_Graph.h SideGamma_Graph_Plot.h SideGamma_Tab_Graph.h
  group include/HardwareInterfaces
    inc/HardwareInterfaces/: adc.h board.h buzzer.h keypad.h lcd.h led.h tone_generator.h
  group include/Logging
    inc/Logging/: Calc_AveAngleMinCurve.h LoggingManager.h
  group include/NVRAM
    inc/NVRAM/: NV_Power.h
  group include/RealTimeClock
    inc/RealTimeCLock/: rtc.h
  group include/SerialFlash
    inc/SerialFlash/: FlashMemory.h
  group include/SerialProtocol
    inc/SerialProtocol/: CSVParser.h PCDataTransfer.h SerialCommon.h TargetProtocol.h
  group include/UI_DataFields
    ../../MWD/Uphole/inc/UI_DataFields/: UI_BooleanField.h UI_DateField.h UI_FixedField.h UI_FixedPointValue.h UI_InitiateField.h UI_ListField.h UI_StringField.h UI_TimeField.h UI_YesNoField.h
  group include/UI_Frame
    inc/UI_Frame/: UI_Frame.h
  group include/UI_Panels
    inc/UI_Panels/: BranchPointSetSuccessPanel.h ClearAllHoleSuccessPanel.h Compass_Panel.h DeleteLastSurveyNotSuccessPanel.h DeleteLastSurveySuccessPanel.h MWD_LoggingPanel.h StartNewHoleSuccessPanel.h SurveyTimeoutPanel.h TakeSurveySuccessPanel.h UI_BranchPointSetDecisionPanel.h UI_ChangePipeLengthCorrectDecisionPanel.h UI_ChangePipeLengthDecisionPanel.h UI_ClearAllHoleDecisionPanel.h UI_DeleteLastSurveyDecisionPanel.h UI_DownholeMainPanel.h UI_EnterNewPipeLength.h UI_EnterSurvey.h UI_EnterSurveyDecisionPanel.h UI_RecordDataPanel.h UI_StartNewHoleDecisionPanel.h UI_SurveyEditPanel.h UI_UpdateDiagnosticDownholeDecisionPanel.h UpdateDownholeSuccessPanel.h UpdateDownholeTimeoutPanel.h UploadingPanel.h WaitingForSurveyPanel.h
  group include/UI_Tabs
    inc/UI_Tabs/: UI_BoxSetupTab.h UI_DataTab.h UI_DownholeTab.h UI_JobTab.h UI_MainTab.h
  group include/UI_Tools
    inc/UI_Tools/: UI_Alphabet.h UI_api.h UI_DataStructures.h UI_Defs.h UI_GroupBox.h UI_LCDScreenInversion.h UI_Primitives.h UI_ScreenUtilities.h
  group include/YitranModem
    inc/YitranModem/: ModemDataHandler.h ModemDataRxHandler.h ModemDataTxHandler.h ModemDriver.h ModemIndicationHandler.h ModemManager.h ModemNetworkHandler.h ModemResponseHandler.h
  group source
    src/: crc.c InterruptEnabling.c main.c NVIC.c PeriodicEvents.c stm32f4xx_it.c system_stm32f4xx.c SysTick.c timer.c UtilityFunctions.c wdt.c
  group source/CommDrivers
    src/CommDrivers/: CommDriver_Flash.c CommDriver_FRAM.c CommDriver_SPI.c CommDriver_UART.c
  group source/DataManagers
    src/DataManagers/: BMP.c DownholeBatteryAndLife.c GammaSensor.c Manager_DataLink.c RecordManager.c TextStrings.c version.c
  group source/Graph_Plot
    src/Graph_Plot/: Compass_Plot.c Gamma_Compass.c Gamma_Graph_Plot.c Gamma_Tab_Graph.c Graph_Plot.c Plan_Graph_Plot.c Plan_Tab_Graph.c Side_Graph_Plot.c Side_Tab_Graph.c SideGamma_Graph_Plot.c SideGamma_Tab_Graph.c
  group source/HardwareInterfaces
    src/HardwareInterfaces/: adc.c buzzer.c keypad.c lcd.c led.c tone_generator.c
  group source/Logging
    src/Logging/: Calc_AveAngleMinCurve.c LoggingManager.c
  group source/NVRAM
    src/NVRAM/: NV_Power.c
  group source/RealTimeClock
    src/RealTimeClock/: rtc.c
  group source/SerialFlash
    src/SerialFlash/: FlashMemory.c
  group source/SerialProtocol
    src/SerialProtocol/: CSVParser.c PCDataTransfer.c TargetProtocol.c
  group source/StdPeriphDrivers
    ../../Libraries/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_usart.c
  group source/UI_DataFields
    src/UI_DataFields/: UI_BooleanField.c UI_DateField.c UI_FixedField.c UI_FixedPointValue.c UI_InitiateField.c UI_ListField.c UI_StringField.c UI_TimeField.c UI_YesNoField.c
  group source/UI_Frame
    src/UI_Frame/: UI_Frame.c UI_FrameAlert.c UI_FrameHome.c UI_FrameLabel.c UI_FrameStartup.c UI_FrameStatus.c UI_FrameTab.c UI_FrameValue.c UI_FrameWindow.c
  group source/UI_Panels
    src/UI_Panels/: BranchPointSetSuccessPanel.c ClearAllHoleSuccessPanel.c Compass_Panel.c DeleteLastSurveyNotSuccessPanel.c DeleteLastSurveySuccessPanel.c MWD_LoggingPanel.c StartNewHoleSuccessPanel.c SurveyTimeoutPanel.c TakeSurveySuccessPanel.c UI_BranchPointSetDecisionPanel.c UI_ChangePipeLengthCorrectDecisionPanel.c UI_ChangePipeLengthDecisionPanel.c UI_ClearAllHoleDecisionPanel.c UI_DeleteLastSurveyDecisionPanel.c UI_DownholeMainPanel.c UI_EnterNewPipeLength.c UI_EnterSurvey.c UI_EnterSurveyDecisionPanel.c UI_RecordDataPanel.c UI_StartNewHoleDecisionPanel.c UI_SurveyEditPanel.c UI_ToolFacePanels.c UI_UpdateDiagnosticDownholeDecisionPanel.c UpdateDownholeSuccessPanel.c UpdateDownholeTimeoutPanel.c UploadingPanel.c WaitingForSurvey.c
  group source/UI_Tabs
    src/UI_Tabs/: UI_BoxSetupTab.c UI_DataTab.c UI_DownholeTab.c UI_JobTab.c UI_MainTab.c
  group source/UI_Tools
    src/UI_Tools/: UI_Alphabet.c UI_GroupBox.c UI_LCDScreenInversion.c UI_Primitives.c UI_ScreenUtilities.c
  group source/YitranModem
    src/YitranModem/: ModemDataHandler.c ModemDataRxHandler.c ModemDataTxHandler.c ModemDriver.c ModemIndicationHandler.c ModemManager.c ModemNetworkHandler.c ModemResponseHandler.c
  group startup
    ../../Libraries/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
