# IAR project Downhole.ewp, settings and files
configuration Downhole (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_PERIPH_LIBRARY; STM32F40_41xxx
  ICCARM.CCIncludePath2: source; inc; ..\..\Libraries\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\Libraries\STM32F4xx_StdPeriph_Driver\inc; inc\CommDrivers; inc\HardwareInterfaces; inc\YitranModem; inc\Sensors; inc\RealTimeClock; ..\..\Libraries\Project\STM32F4xx_StdPeriph_Templates; inc\SerialProtocol; inc\SerialFlash
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Downhole.bin
  ILINK.IlinkOutputFile: Downhole.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group include
    inc/: crc.h InterruptEnabling.h main.h UtilityFunctions.h version.h wdt.h
  group include/CommDrivers
    inc/CommDrivers/: CommDriver_Flash.h CommDriver_SPI.h CommDriver_UART.h
  group include/HardwareInterfaces
    inc/HardwareInterfaces/: adc.h board.h led.h power.h testio.h
  group include/RealTimeClock
    inc/RealTimeClock/: NV_Power.h RealTimeClock.h SysTick.h
  group include/Sensors
    inc/Sensors/: compass.h SensorManager_Gamma.h
  group include/SerialFlash
    inc/SerialFlash/: FlashMemory.h
  group include/SerialProtocol
    inc/SerialProtocol/: SerialCommon.h TargetProtocol.h
  group include/STM-Periph-Drivers
    ../../Libraries/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_adc.h stm32f4xx_crc.h stm32f4xx_dma.h stm32f4xx_gpio.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rtc.h stm32f4xx_spi.h stm32f4xx_tim.h stm32f4xx_usart.h
  group include/YitranModem
    inc/YitranModem/: ModemDataHandler.h ModemDataRxHandler.h ModemDataTxHandler.h ModemDriver.h ModemIndicationHandler.h ModemManager.h ModemNetworkHandler.h ModemResponseHandler.h
  group source
    src/: crc.c InterruptEnabling.c main.c system_stm32f4xx.c UtilityFunctions.c version.c wdt.c
  group source/CommDrivers
    src/CommDrivers/: CommDriver_Flash.c CommDriver_SPI.c CommDriver_UART.c
  group source/HardwareInterfaces
    src/HardwareInterfaces/: adc.c led.c power.c testio.c
  group source/RealTimeClock
    src/RealTimeClock/: NV_Power.c RealTimeClock.c SysTick.c
  group source/Sensors
    src/Sensors/: compass.c SensorManager_Gamma.c
  group source/SerialFlash
    src/SerialFlash/: FlashMemory.c
  group source/SerialProtocol
    src/SerialProtocol/: TargetProtocol.c
  group source/STM-Periph-Drivers
    ../../Libraries/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    src/: stm32f4xx_it.c
  group source/YitranModem
    src/YitranModem/: ModemDataHandler.c ModemDataRxHandler.c ModemDataTxHandler.c ModemDriver.c ModemIndicationHandler.c ModemManager.c ModemNetworkHandler.c ModemResponseHandler.c
  group startup
    ../../Libraries/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
